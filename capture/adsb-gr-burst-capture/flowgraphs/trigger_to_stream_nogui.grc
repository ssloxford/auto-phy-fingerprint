options:
  parameters:
    generate_options: no_gui
    id: trigger_to_stream_nogui
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filename
  id: variable
  parameters:
    value: '"/radio/adsb_" + str(samp_rate) + "_" + str(int(time.time())) + ".sdrbf"'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /radio/adsb-mini.cf32
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: streamer_BurstStreamer_0
  id: streamer_BurstStreamer
  parameters:
    bind_addr: tcp://172.17.0.3:5678
  states: {}
- name: triggers_DoubleSlidingWindowTrigger_0
  id: triggers_DoubleSlidingWindowTrigger
  parameters:
    dontstopbeforeparam: '160'
    maxoutbuf: 2**20
    minoutbuf: 2**20
    pdusampcountparam: '2500'
    thresholdparam: '8'
    windowsizeparam: '200'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 3e6
    center_freq0: 1090e6
    dc_offs_enb0: '""'
    dev_args: '"num_recv_frames=1024"'
    gain0: '55'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', triggers_DoubleSlidingWindowTrigger_0, '0']
- [triggers_DoubleSlidingWindowTrigger_0, '0', streamer_BurstStreamer_0, '0']
- [uhd_usrp_source_0, '0', triggers_DoubleSlidingWindowTrigger_0, '0']

metadata:
  file_format: 1
