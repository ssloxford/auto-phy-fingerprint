options:
  parameters:
    generate_options: no_gui
    id: trigger_to_burstfile_nogui
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filename
  id: variable
  parameters:
    value: '"/radio/adsb_" + str(samp_rate) + "_" + str(int(time.time())) + ".sdrbf"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /radio/adsb-mini.cf32
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: burstfile_BurstfileWriter_0
  id: burstfile_BurstfileWriter
  parameters:
    filename: filename
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.5'
  states: {state: disabled}
- name: triggers_DoubleSlidingWindowTrigger_0
  id: triggers_DoubleSlidingWindowTrigger
  parameters:
    dontstopbeforeparam: '160'
    pdusampcountparam: '2500'
    thresholdparam: '10'
    windowsizeparam: '200'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 3e6
    center_freq0: 1090e6
    dc_offs_enb0: '""'
    dev_args: '"num_recv_frames=1024"'
    gain0: '55'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', triggers_DoubleSlidingWindowTrigger_0, '0']
- [triggers_DoubleSlidingWindowTrigger_0, '0', burstfile_BurstfileWriter_0, '0']
- [triggers_DoubleSlidingWindowTrigger_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', triggers_DoubleSlidingWindowTrigger_0, '0']

metadata:
  file_format: 1
